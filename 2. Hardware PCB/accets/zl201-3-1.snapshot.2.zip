# Pro/ENGINEER part, saved by Pro/ENGINEER Wildfire 2.0 (file zl201-3_p2-54_l7-62_w2-54_h8-89.prt.1)

Parameters:
  PTC_COMMON_NAME = "pinh-1v_p2-54_l2-54_w2-54_h8-89.prt"